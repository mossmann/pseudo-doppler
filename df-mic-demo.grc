options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: antenna_position
  id: variable
  parameters:
    value: (1, 0+1j, -1, 0-1j)
  states: {}
- name: antennas
  id: variable
  parameters:
    value: '4'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 504.725e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: e
  id: variable
  parameters:
    value: math.e
  states: {}
- name: radius
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: rotation_rate
  id: variable
  parameters:
    value: samp_rate/(samples_per_rotation+0.5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samples_per_antenna
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samples_per_rotation
  id: variable
  parameters:
    value: samples_per_antenna * antennas
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/(decimation*2)
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/(decimation*2)
    win: window.WIN_HAMMING
  states: {}
- name: tau
  id: variable
  parameters:
    value: 2*math.pi
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '500'
  states: {}
- name: tuning_freq
  id: variable
  parameters:
    value: 503e6
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: c/carrier_freq
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.2'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-rotation_rate'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decimation
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: rotation_rate*1.05
    low_cutoff_freq: rotation_rate*.95
    samp_rate: samp_rate/decimation
    type: fir_filter_ccc
    width: rotation_rate/4
    win: window.WIN_HAMMING
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/6.2831853
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold/2
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 6.28/100
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate/decimation
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq-tuning_freq
    decim: decimation
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/100
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: samp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '16'
    freq0: tuning_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.2'
    grid: 'True'
    nconnections: '2'
    size: '100'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: complex
    xmax: '0.05'
    xmin: '-0.05'
    ymax: '0.05'
    ymin: '-0.05'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    label3: ''
    nconnections: '3'
    size: '1024'
    srate: samp_rate/decimation
    tr_chan: '1'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ymax: '180'
    ymin: '-180'
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '.01'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_burst_tagger_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_burst_tagger_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [osmosdr_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-352-g6efdc9d8
